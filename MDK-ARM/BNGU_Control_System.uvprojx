# Keil uVision project BNGU_Control_System.uvprojx, settings and files
target BNGU_Control_System (6240000::V6.24::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BNGU_Control_System +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Self_core/App/common/communication;../Self_core/App/common/system;../Self_core/App/sentry/chassis;../Self_core/App/sentry/gimbal;../Self_core/Bsp;../Self_core/Drv/Drv_buzzer;../Self_core/Drv/Drv_dbus;../Self_core/Drv/Drv_imu;../Self_core/Drv/Drv_led;../Self_core/Drv/Drv_motor;../Self_core/Drv/Drv_power_measure;../Self_core/Drv/Drv_vofa;../Self_core/Drv/Drv_referee;../Self_core/Lib/Lib_filter;../Self_core/Lib/Lib_math;../Self_core/Lib/Lib_pid;../Self_core/Lib/Lib_Typedef;../Self_core;../Self_core/App/sentry;../Self_core/App/Armored;../Self_core/App/Armored/chassis/ui_generated;../Self_core/Drv/Drv_mag;../Self_core/App/common/diagnostic;../Self_core/Drv/Drv_melody
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Self_core\App\common\communication
    ../Self_core/App/common/communication/: app_chassis_comm.c app_gimbal_comm.c
  group Self_core\App\common\system
    ../Self_core/App/common/system/: app_control.c app_init.c
  group Self_core\App\sentry\chassis
    ../Self_core/App/sentry/chassis/: app_sentry_chassis.c
  group Self_core\App\sentry\gimbal
    ../Self_core/App/sentry/gimbal/: app_sentry_gimbal.c
    ../Self_core/App/sentry/: app_sentry_common.h
  group Self_core\Bsp
    ../Self_core/Bsp/: bsp_adc.c bsp_can.c bsp_flash.c bsp_gpio.c bsp_i2c.c bsp_spi.c bsp_tim.c bsp_uart.c
  group Self_core\Drv\Drv_buzzer
    ../Self_core/Drv/Drv_buzzer/: drv_buzzer.c drv_buzzer_port.c
  group Self_core\Drv\Drv_dbus
    ../Self_core/Drv/Drv_dbus/: drv_dbus.c drv_dbus_port.c
  group Self_core\Drv\Drv_imu
    ../Self_core/Drv/Drv_imu/: drv_imu.c drv_imu_ekf.c drv_imu_vqf.c drv_imu_port.c
  group Self_core\Drv\Drv_led
    ../Self_core/Drv/Drv_led/: drv_led.c drv_led_port.c
  group Self_core\Drv\Drv_motor
    ../Self_core/Drv/Drv_motor/: drv_motor.c drv_motor_port.c drv_motor_dm_reg.h
  group Self_core\Drv\Drv_power_measure
    ../Self_core/Drv/Drv_power_measure/: drv_power_measure.c drv_power_measure_port.c
  group Self_core\Drv\Drv_referee
    ../Self_core/Drv/Drv_referee/: drv_referee.c drv_referee_port.c
  group Self_core\Drv\Drv_vofa
    ../Self_core/Drv/Drv_vofa/: drv_vofa.c drv_vofa_port.c
  group Self_core\Lib\Lib_filter
    ../Self_core/Lib/Lib_filter/: lib_filter.c
  group Self_core\Lib\Lib_math
    ../Self_core/Lib/Lib_math/: lib_math.c
  group Self_core\Lib\Lib_pid
    ../Self_core/Lib/Lib_pid/: lib_pid.c
  group Self_core\App\Armored
    ../Self_core/App/Armored/chassis/: app_Armored_joint.c app_Armored_joint.h app_Armored_mecanum.c app_Armored_mecanum.h app_Armored_ui.c app_Armored_ui.h
    ../Self_core/App/Armored/chassis/ui_generated/: ui.h ui_g.c ui_g.h ui_interface.c ui_interface.h ui_types.h
  group Self_core\Drv\Drv_mag
    ../Self_core/Drv/Drv_mag/: drv_mag.c drv_mag_port.c drv_mag_port.h
  group Self_core\Drv\Drv_melody
    ../Self_core/Drv/Drv_melody/: drv_melody.c
  group Self_core\App\common\diagnostic
    ../Self_core/App/common/diagnostic/: app_diagnostic.c
  group Self_core\App\Navigation
    ../Self_core/App/Navigation/: chassis.c chassis.h Navigation_cfg.h navigation_ctrl.c navigation_ctrl.h
  group H:\BNGU_Control_System_test\Self_core\Drv\Drv_game_controller
    ../Self_core/Drv/Drv_game_controller/: drv_game_controller.c drv_game_controller.h drv_game_controller_port.c
software components: CMSIS:CORE 6.1.1
